# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx
  c misc: --C99
  c include: ../;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group /MDK-ARM
    ../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l053xx.s
  group User
    ../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ../: main.c
software components: CMSIS:CORE 4.1.0
