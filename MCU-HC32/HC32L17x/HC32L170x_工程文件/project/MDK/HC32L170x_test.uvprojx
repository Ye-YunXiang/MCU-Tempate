# Keil uVision project HC32L170x_test.uvprojx, settings and files
target HC32L170x_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L170JATA HDSC
  pack: HDSC.HC32L17X.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L170x_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\source;..\user;..\..\common;..\..\driver\inc;..\..\driver\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ../../common/: interrupts_hc32l17x.c system_hc32l17x.c startup_hc32l17x.s
  group driver
    ../../driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group source
    ../source/: main.c
software components: CMSIS:CORE 5.2.0
